# Keil uVision project 2019_IFR_Preliminary-Sentry_YuXin.uvproj, settings and files
target 2019_RM_Preliminary_Sentry_YuXin (ARM-ADS)
  device: STM32F427II STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: 2019_IFR_Preliminary-Sentry_YuXin +hex
  c flags: Optim=1 uC99=1 wLevel=2
  c define: STM32F427_437xx,USE_STDPERIPH_DRIVER,__FPU_USED,__FPU_PRESENT,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\USER;..\STM32MCU;..\STM32MCU\FWLIB\inc;..\STM32MCU\CORE;..\ROBOT\ALGO;..\ROBOT\ANALYSIS;..\ROBOT\APP;..\ROBOT\BSP
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../USER/: main.c MyDefine.h
    ../: readme.md
  group APP
    ../ROBOT/APP/: sys.c control.c led_control.c yun.c chassis.c shoot.c protect.c auto_aim.c auto_move.c wifi_debug.c friction_wheel.c brain.c heat_limit.c
  group BSP
    ../ROBOT/BSP/: bsp.c can1.c can2.c delay.c gpio_key.c gpio_laster.c gpio_led.c gpio_power.c pwm.c pwm_buzzer.c pwm_imuheat.c SPI5_imu.c timer6.c usart1_remote.c usart2_wifidebug.c usart3_judge.c usart6_viceboard.c uart7_vision.c
  group STM32MCU
    ../STM32MCU/: stm32f4xx_it.c system_stm32f4xx.c
    ../STM32MCU/CORE/: startup_stm32f427_437xx.s
    ../STM32MCU/FWLIB/src/: misc.c stm32f4xx_can.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group ANALYSIS
    ../ROBOT/ANALYSIS/: can1_analysis.c can2_analysis.c imu_analysis.c usart1_remote_analysis.c usart2_wifidebug_analysis.c usart3_judge_analysis.c uart7_vision_analysis.c usart6_viceboard_analysis.c
  group ALGO
    ../ROBOT/ALGO/: pid.c Kalman_Filter.c quaternion.c CRC_check.c
